# Keil uVision project ota.uvprojx, settings and files
target ota (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  AfterMake: fromelf --bin --output ./out.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: ..\USER;..\CMSIS\Include;..\HW\Include;..\LIB\Include;..\Middlewares\FreeRTOS\inc;..\Middlewares\FreeRTOS\port;..\APP;..\Middlewares;..\LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c onenet_app.c onenet_app.h task_wdt.c task_wdt.h
  group CMSIS
    ../CMSIS/Source/: system_gd32f10x.c startup_gd32f10x_md.s
  group HW
    ../HW/Source/: gd32f10x_it.c usart.c hw_i2c.c delay.c hw_spi.c hw_flash.c hw_cpu.c hw_usart1.c hw_wdt.c
    ../HW/Include/: gd32f10x_it.h hw_i2c.h usart.h delay.h hw_spi.h hw_flash.h hw_cpu.h hw_usart1.h hw_wdt.h
  group LIB
    ../LIB/Source/: gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_gpio.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_spi.c gd32f10x_fmc.c gd32f10x_wwdgt.c gd32f10x_fwdgt.c
  group MIDDLEWARE
    ../Middlewares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/port/: heap_4.c port.c
    ../Middlewares/FreeRTOS/inc/: FreeRTOSConfig.h
    ../Middlewares/: os_port.c os_port.h esp8266_at.c esp8266_at.h
  group APP
    ../APP/: sys_param.c sys_param.h at24c02.c at24c02.h w25q64.c w25q64.h ota_fsm.c ota_fsm.h ota_logic.c
